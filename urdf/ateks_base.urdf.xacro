Commit message: first commit

File: urdf/ateks_base.urdf.xacro (robot description, xacro)
@@ -62,5 +62,4 @@
     </joint>
     <!--____________________ second kinect joint and links _______________________________-->
-    </link>
     <link name="kinect_dummy2">
       <pose>0 0 0 0 0 0</pose>
